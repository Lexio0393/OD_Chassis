# Keil uVision project STM32F407-SONIC.uvprojx, settings and files
target SONIC (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F407-SONIC
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,__FPU_PRESENT=1,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\Libraries\CMSIS;..\Libraries\CMSIS\startup;..\Libraries\dsplib\Include;..\Libraries\dsplib\Include;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Libraries;..\User\User_Driver\inc;..\User\User_App;..\User\User_Algorithm;..\User\User_Connector
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User_Driver
    ../User/User_Driver/src/: bsp_main.c bsp_systick.c bsp_io.c bsp_can.c bsp_serial.c bsp_timer.c bsp_dma.c
  group User_Algorithm
    ../User/User_Algorithm/: algorithm.c pid.c chassis.c motion.h
  group User_App
    ../User/User_App/: main.c stm32f4xx_it.c C620.c pps.c task.c bsp_dt7.c
  group User_Connector
    ../User/User_Connector/: pack_deal.c
  group CMSIS
    ../Libraries/CMSIS/: system_stm32f4xx.c
    ../Libraries/: arm_cortexM4lf_math.lib
  group Startup
    ../Libraries/CMSIS/startup/: startup_stm32f40_41xxx.s
  group stm32f4xx_StdPeriph_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_can.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_sdio.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_dma.c
